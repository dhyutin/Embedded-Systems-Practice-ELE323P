# Keil uVision project lab2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123BE6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: lab2
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: PLL.c PLL.h startup.s example.c
